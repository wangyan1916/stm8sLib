# IAR project lib.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: D:\Files\stm8\stm8s\lib; D:\Files\stm8\stm8s\lib\STM8S_StdPeriph_Driver\inc; D:\Files\stm8\stm8s\lib\STM8S_StdPeriph_Driver\src; C:\Files\stm8\stm8sLib\STM8S_StdPeriph_Driver\inc; C:\Files\stm8\stm8sLib\STM8S_StdPeriph_Driver\src; C:\Files\stm8\stm8sLib
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: lib.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group STM8S_StdPeriph_Driver
    STM8S_StdPeriph_Driver/src/: stm8s_exti.c stm8s_gpio.c
  group USER
    ./: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
